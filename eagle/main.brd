# Repository mjgardes/FUSERATOR

File README.md:

FUSERATOR
=========

Hardware and software for a cheap toner transfer press.

## EAGLE design eagle/main.brd

Parts:
430: PINHD-2X7; 2X07
C1, C2, C3: C-USC0603K; C0603K
C4: CPOL-USE2.5-7; E2,5-7
IC1, IC4: 74LS595D; SO16
IC3: 317EMP; SOT223
J1, J2: MTA02-100; 10X02MTA
JP2: PINHD-1X6; 1X06
Q1, Q2, Q3, Q4, Q5: BSS123; SOT23
R1, R2, R4: 0; R0603
R3: 720ish; R0805
S1, S2, S3: 10-XX; B3F-10XX
U$1: BL-T52C-31; BL-T52X-31

Connections:
+5V: IC3.3 (VI), J1.2, JP2.4
GND: 430.2, 430.13, C4.-, IC1.8 (GND), IC1.13 (G), IC3.1 (ADJ), IC4.8 (GND), IC4.13 (G), J1.1, J2.2, JP2.2, JP2.3, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), S1.3, S1.4 (P1), S2.3, S2.4 (P1), S3.3, S3.4 (P1); also elsewhere on the board
unnamed: IC4.15 (QA), U$1.P$8
unnamed: IC4.1 (QB), U$1.P$9
unnamed: IC4.7 (QH), U$1.P$1
unnamed: IC4.6 (QG), U$1.P$2
unnamed: IC4.5 (QF), U$1.P$3
unnamed: IC4.4 (QE), U$1.P$4
unnamed: IC4.3 (QD), U$1.P$5
unnamed: IC4.2 (QC), U$1.P$12
unnamed: Q1.3 (D), U$1.P$11
unnamed: Q2.3 (D), U$1.P$10
unnamed: Q3.3 (D), U$1.P$7
unnamed: IC1.3 (QD), Q1.1 (G)
unnamed: 430.14, IC1.14 (SER)
unnamed: IC4.14 (SER), R2.2
unnamed: 430.7, C3.1, S1.1 (S), S1.2 (S1)
unnamed: IC1.9 (QH*), R1.1
unnamed: 430.11, J2.1, JP2.1, R3.1
unnamed: 430.3, C1.1, S3.1 (S), S3.2 (S1)
unnamed: R1.2, R2.1
unnamed: IC1.1 (QB), Q4.1 (G)
unnamed: IC1.11 (SCK), IC4.11 (SCK), R4.2
unnamed: IC1.4 (QE), Q2.1 (G)
unnamed: JP2.5, Q4.3 (D)
unnamed: IC1.5 (QF), Q3.1 (G)
unnamed: IC1.2 (QC), Q5.1 (G)
unnamed: 430.12, R4.1
unnamed: JP2.6, Q5.3 (D)
unnamed: 430.5, C2.1, S2.1 (S), S2.2 (S1)
unnamed: 430.6, IC1.12 (RCK), IC4.12 (RCK)
unnamed 32: 430.9, R3.2; also elsewhere on the board
VCC: 430.1, C1.2, C2.2, C3.2, C4.+, IC1.10 (SCL), IC1.16 (VCC), IC3.4 (VO), IC4.10 (SCL), IC4.16 (VCC)

Board: 2 copper layers, 73.0 x 41.3 mm, 25 parts (18 on the bottom side), 33 nets.

Other parts of the board:
C5: 470nF; C0603K

Their connections:
GND: C5.1; also elsewhere on the board
unnamed 32: C5.2; also elsewhere on the board

## Commit log

2012-09-23 Adding hardware design. Preliminary stage. Chances are none of it will work.
2012-09-23 Read datasheets, modified to actually use the correct msp430 pins. Added proper connector to relay board and generated mask files
2012-09-24 added .cam file for those who like my CAM processor settings
2012-09-24 The 430 might not blow up after these edits
2012-09-24 added my library for the regulator
2012-09-24 gotta keep organized
2012-09-24 updated values and added example parts order for Newark
2012-09-24 added hole pattern. ready to print, i think.
2012-09-24 regenerated masks to reflect design changes
2012-09-24 Lots of hw changes and swapped parts. Maybe your FTDI chip won't blow up with this one.
2012-09-24 Little tweaks. warning: scribus file is not consistent due to crashiness.
2012-10-10 Fixed up the layout a little, made the mask files consistent
2012-10-15 HW design is broken. Software stub to test LED display.
2012-10-15 more friendly LED test
2012-10-17 snapshot before porting code to v4 hardware
2012-11-27 another big revamp
2012-11-28 EPS and odt layout files should be consistent with bed and msp430 codes. note that none of this actually works yet.
2012-11-28 pin reassignments
2012-11-30 Temperature control is working.
2012-12-01 Tidied up the swath of damage i put in last night.
2012-12-01 Played around with the thermistor model a bit to tweak it a little closer to reality.
2012-12-01 More tweaks to the board.
